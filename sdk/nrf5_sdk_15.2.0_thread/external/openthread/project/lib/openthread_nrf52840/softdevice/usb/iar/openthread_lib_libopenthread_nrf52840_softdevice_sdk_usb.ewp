# IAR project openthread_lib_libopenthread_nrf52840_softdevice_sdk_usb.ewp, settings and files
configuration libopenthread_nrf52840_softdevice_sdk_usb (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: CONFIG_GPIO_AS_PINRESET; DISABLE_CC310=1; ENABLE_FEM=1; FLOAT_ABI_HARD; HAVE_CONFIG_H; MBEDTLS_CONFIG_FILE="mbedtls-config.h"; MBEDTLS_USER_CONFIG_FILE="nrf52840-mbedtls-config.h"; NRF52840_XXAA; NRF_802154_PROJECT_CONFIG="platform-config.h"; OPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED; OPENTHREAD_PROJECT_CORE_CONFIG_FILE="openthread-core-nrf52840-config.h"; RAAL_SOFTDEVICE=1; S140; SOFTDEVICE_PRESENT; USB_CDC_AS_SERIAL_TRANSPORT=1; _BSD_SOURCE=1; _DEFAULT_SOURCE=1
  ICCARM.CCIncludePath2: ..\..\..\..\..\config; ..\..\..\..\..\openthread\examples\platforms; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio; ..\..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..; ..\..\..\..\..\openthread\examples\platforms\nrf52840; ..\..\..\..\..\openthread\include; ..\..\..\..\..\openthread\src\core; ..\..\..\..\..\openthread\third_party\NordicSemiconductor; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\cmsis; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\dependencies; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\clock; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\common; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\power; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\hal; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\raal; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\raal\softdevice; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\systick; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\usbd; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\app_error; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\atfifo; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\atomic; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\crypto; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\delay; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\nrf_cc310\include; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb\class\cdc; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb\class\cdc\acm; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb\config; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\utf_converter; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\drivers; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\drivers\include; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\hal; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\mdk; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\soc; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\segger_rtt; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\softdevice\s140\headers; ..\..\..\..\..\openthread\third_party\mbedtls; ..\..\..\..\..\openthread\third_party\mbedtls\repo\include; ..\..\..\..\..\openthread\third_party\mbedtls\repo\include\mbedtls
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: openthread_lib_libopenthread_nrf52840_softdevice_sdk_usb.hex
  ILINK.IlinkOutputFile: openthread_lib_libopenthread_nrf52840_softdevice_sdk_usb.out
  ILINK.IlinkIcfFile: openthread_lib_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group openthread
    ../../../../../openthread/third_party/NordicSemiconductor/libraries/crypto/: aes_alt.c aes_alt_cc310.c aes_alt_soft.c cc310_mbedtls.c ecp_alt_cc310.c ecp_curves_alt.c sha256_alt_cc310.c
    ../../../../../openthread/examples/platforms/nrf52840/: alarm.c diag.c fem.c flash.c flash_sd.c logging.c misc.c radio.c random.c softdevice.c spi-slave.c system.c temp.c uart.c usb-cdc-uart.c
    ../../../../../openthread/third_party/NordicSemiconductor/drivers/radio/: nrf_802154.c nrf_802154_ack_pending_bit.c nrf_802154_core.c nrf_802154_core_hooks.c nrf_802154_critical_section.c nrf_802154_debug.c nrf_802154_notification_swi.c nrf_802154_pib.c nrf_802154_priority_drop_swi.c nrf_802154_request_swi.c nrf_802154_revision.c nrf_802154_rsch.c nrf_802154_rssi.c nrf_802154_rx_buffer.c nrf_802154_swi.c nrf_802154_timer_coord.c
    ../../../../../openthread/third_party/NordicSemiconductor/drivers/radio/mac_features/: nrf_802154_ack_timeout.c nrf_802154_csma_ca.c nrf_802154_delayed_trx.c nrf_802154_filter.c
    ../../../../../openthread/third_party/NordicSemiconductor/drivers/radio/platform/clock/: nrf_802154_clock_sdk.c
    ../../../../../openthread/third_party/NordicSemiconductor/drivers/radio/platform/hp_timer/: nrf_802154_hp_timer.c
    ../../../../../openthread/third_party/NordicSemiconductor/drivers/radio/timer_scheduler/: nrf_802154_timer_sched.c
    ../../../../../openthread/third_party/NordicSemiconductor/drivers/radio/fem/: nrf_fem_control.c
    ../../../../../openthread/third_party/NordicSemiconductor/drivers/radio/raal/softdevice/: nrf_raal_softdevice.c
