# Keil uVision project openthread_lib_libopenthread_nrf52840_softdevice_sdk_usb.uvprojx, settings and files
target libopenthread_nrf52840_softdevice_sdk_usb (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: ..
  output: libopenthread-nrf52840-softdevice-sdk-usb (library)
  c flags: Optim=s OneElfS=1 uC99=1
  c define: CONFIG_GPIO_AS_PINRESET DISABLE_CC310=1 ENABLE_FEM=1 FLOAT_ABI_HARD HAVE_CONFIG_H MBEDTLS_CONFIG_FILE=\"mbedtls-config.h\" MBEDTLS_USER_CONFIG_FILE=\"nrf52840-mbedtls-config.h\" NRF52840_XXAA NRF_802154_PROJECT_CONFIG=\"platform-config.h\" OPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED OPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52840-config.h\" RAAL_SOFTDEVICE=1 S140 SOFTDEVICE_PRESENT USB_CDC_AS_SERIAL_TRANSPORT=1 _BSD_SOURCE=1 _DEFAULT_SOURCE=1 __HEAP_SIZE=4096 __STACK_SIZE=4096
  c misc: --reduce_paths
  c include: ..\..\..\..\..\config;..\..\..\..\..\openthread\examples\platforms;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio;..\..\..\..\..;..\..\..\..\..\openthread\examples\platforms\nrf52840;..\..\..\..\..\openthread\include;..\..\..\..\..\openthread\src\core;..\..\..\..\..\openthread\third_party\NordicSemiconductor;..\..\..\..\..\openthread\third_party\NordicSemiconductor\cmsis;..\..\..\..\..\openthread\third_party\NordicSemiconductor\dependencies;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\clock;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\common;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\power;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\hal;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\raal;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\raal\softdevice;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\systick;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\usbd;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\app_error;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\atfifo;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\atomic;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\crypto;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\delay;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\nrf_cc310\include;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb\class\cdc;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb\class\cdc\acm;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb\config;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\utf_converter;..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx;..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\drivers;..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\drivers\include;..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\hal;..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\mdk;..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\soc;..\..\..\..\..\openthread\third_party\NordicSemiconductor\segger_rtt;..\..\..\..\..\openthread\third_party\NordicSemiconductor\softdevice\s140\headers;..\..\..\..\..\openthread\third_party\mbedtls;..\..\..\..\..\openthread\third_party\mbedtls\repo\include;..\..\..\..\..\openthread\third_party\mbedtls\repo\include\mbedtls
  asm define: as above
  asm misc: --cpreproc_opts=-DCONFIG_GPIO_AS_PINRESET,-DDISABLE_CC310=1,-DENABLE_FEM=1,-DFLOAT_ABI_HARD,-DHAVE_CONFIG_H,-DMBEDTLS_CONFIG_FILE=\"mbedtls-config.h\",-DMBEDTLS_USER_CONFIG_FILE=\"nrf52840-mbedtls-config.h\",-DNRF52840_XXAA,-DNRF_802154_PROJECT_CONFIG=\"platform-config.h\",-DOPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED,-DOPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52840-config.h\",-DRAAL_SOFTDEVICE=1,-DS140,-DSOFTDEVICE_PRESENT,-DUSB_CDC_AS_SERIAL_TRANSPORT=1,-D_BSD_SOURCE=1,-D_DEFAULT_SOURCE=1,-D__HEAP_SIZE=4096,-D__STACK_SIZE=4096
  asm include: as above
  library: MicroLIB
  link misc: --diag_suppress 6330
  group openthread
    ../../../../../openthread/third_party/NordicSemiconductor/libraries/crypto/: aes_alt.c aes_alt_cc310.c aes_alt_soft.c cc310_mbedtls.c ecp_alt_cc310.c ecp_curves_alt.c sha256_alt_cc310.c
    ../../../../../openthread/examples/platforms/nrf52840/: alarm.c diag.c fem.c flash.c flash_sd.c logging.c misc.c radio.c random.c softdevice.c spi-slave.c system.c temp.c uart.c usb-cdc-uart.c
    ../../../../../openthread/third_party/NordicSemiconductor/drivers/radio/: nrf_802154.c nrf_802154_ack_pending_bit.c nrf_802154_core.c nrf_802154_core_hooks.c nrf_802154_critical_section.c nrf_802154_debug.c nrf_802154_notification_swi.c nrf_802154_pib.c nrf_802154_priority_drop_swi.c nrf_802154_request_swi.c nrf_802154_revision.c nrf_802154_rsch.c nrf_802154_rssi.c nrf_802154_rx_buffer.c nrf_802154_swi.c nrf_802154_timer_coord.c
    ../../../../../openthread/third_party/NordicSemiconductor/drivers/radio/mac_features/: nrf_802154_ack_timeout.c nrf_802154_csma_ca.c nrf_802154_delayed_trx.c nrf_802154_filter.c
    ../../../../../openthread/third_party/NordicSemiconductor/drivers/radio/platform/clock/: nrf_802154_clock_sdk.c
    ../../../../../openthread/third_party/NordicSemiconductor/drivers/radio/platform/hp_timer/: nrf_802154_hp_timer.c
    ../../../../../openthread/third_party/NordicSemiconductor/drivers/radio/timer_scheduler/: nrf_802154_timer_sched.c
    ../../../../../openthread/third_party/NordicSemiconductor/drivers/radio/fem/: nrf_fem_control.c
    ../../../../../openthread/third_party/NordicSemiconductor/drivers/radio/raal/softdevice/: nrf_raal_softdevice.c
