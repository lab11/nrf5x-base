# IAR project ot_nrf52840_libnordicsemi_nrf52840_radio_driver_softdevice.ewp, settings and files
configuration libnordicsemi_nrf52840_radio_driver_softdevice (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: CONFIG_GPIO_AS_PINRESET; ENABLE_FEM=1; FLOAT_ABI_HARD; HAVE_CONFIG_H; MBEDTLS_CONFIG_FILE="mbedtls-config.h"; MBEDTLS_USER_CONFIG_FILE="nrf52840-mbedtls-config.h"; NRF52840_XXAA; NRF_802154_PROJECT_CONFIG="platform-config.h"; OPENTHREAD_CONFIG_ENABLE_SLAAC=1; OPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED; OPENTHREAD_PROJECT_CORE_CONFIG_FILE="openthread-core-nrf52840-config.h"; RAAL_SOFTDEVICE=1; S140; SOFTDEVICE_PRESENT; UART_AS_SERIAL_TRANSPORT=1; _BSD_SOURCE=1; _DEFAULT_SOURCE=1
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio; ..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\openthread\examples\platforms\nrf52840; ..\..\..\..\openthread\include; ..\..\..\..\openthread\src\core; ..\..\..\..\openthread\third_party\NordicSemiconductor; ..\..\..\..\openthread\third_party\NordicSemiconductor\cmsis; ..\..\..\..\openthread\third_party\NordicSemiconductor\dependencies; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\clock; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\common; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\power; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\hal; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\mac_features; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\mac_features\ack_generator; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\rsch; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\rsch\raal; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\rsch\raal\softdevice; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\systick; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\usbd; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\app_error; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\atfifo; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\atomic; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\crypto; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\delay; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\nrf_cc310\include; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb\class\cdc; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb\class\cdc\acm; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb\config; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\utf_converter; ..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx; ..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\drivers; ..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\drivers\include; ..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\hal; ..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\mdk; ..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\soc; ..\..\..\..\openthread\third_party\NordicSemiconductor\softdevice\s140\headers; ..\..\..\..\openthread\third_party\NordicSemiconductor\softdevice\s140\headers\nrf52; ..\..\..\..\openthread\third_party\mbedtls; ..\..\..\..\openthread\third_party\mbedtls\repo\include; ..\..\..\..\openthread\third_party\mbedtls\repo\include\mbedtls
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ot_nrf52840_libnordicsemi_nrf52840_radio_driver_softdevice.hex
  ILINK.IlinkOutputFile: ot_nrf52840_libnordicsemi_nrf52840_radio_driver_softdevice.out
  ILINK.IlinkIcfFile: ot_nrf52840_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group openthread
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/: nrf_802154.c nrf_802154_ack_pending_bit.c nrf_802154_core.c nrf_802154_core_hooks.c nrf_802154_critical_section.c nrf_802154_debug.c nrf_802154_notification_swi.c nrf_802154_pib.c nrf_802154_priority_drop_swi.c nrf_802154_request_swi.c nrf_802154_revision.c nrf_802154_rssi.c nrf_802154_rx_buffer.c nrf_802154_swi.c nrf_802154_timer_coord.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/mac_features/ack_generator/: nrf_802154_ack_data.c nrf_802154_ack_generator.c nrf_802154_enh_ack_generator.c nrf_802154_imm_ack_generator.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/platform/clock/: nrf_802154_clock_sdk.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/mac_features/: nrf_802154_csma_ca.c nrf_802154_delayed_trx.c nrf_802154_filter.c nrf_802154_frame_parser.c nrf_802154_precise_ack_timeout.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/platform/hp_timer/: nrf_802154_hp_timer.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/rsch/: nrf_802154_rsch.c nrf_802154_rsch_crit_sect.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/timer_scheduler/: nrf_802154_timer_sched.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/fem/: nrf_fem_control.c
    ../../../../openthread/third_party/NordicSemiconductor/drivers/radio/rsch/raal/softdevice/: nrf_raal_softdevice.c
