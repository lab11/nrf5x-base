# Keil uVision project ot_nrf52840_libopenthread_nrf52840_softdevice_sdk_spi.uvprojx, settings and files
target libopenthread_nrf52840_softdevice_sdk_spi (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: ..
  output: libopenthread-nrf52840-softdevice-sdk-spi (library)
  c flags: Optim=s OneElfS=1 uC99=1
  c define: CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD HAVE_CONFIG_H MBEDTLS_CONFIG_FILE=\"mbedtls-config.h\" MBEDTLS_USER_CONFIG_FILE=\"nrf52840-mbedtls-config.h\" NRF52840_XXAA OPENTHREAD_CONFIG_ENABLE_SLAAC=1 OPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED OPENTHREAD_ENABLE_NCP_SPI=1 OPENTHREAD_ENABLE_NCP_UART=0 OPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52840-config.h\" S140 SOFTDEVICE_PRESENT SPIS_AS_SERIAL_TRANSPORT=1 _BSD_SOURCE=1 _DEFAULT_SOURCE=1 __HEAP_SIZE=4096 __STACK_SIZE=4096
  c misc: --reduce_paths
  c include: ..\..\..\..\config;..\..\..\..\..\openthread\examples\platforms;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio;..\..\..\..;..\..\..\..\..\openthread\examples\platforms\nrf52840;..\..\..\..\..\openthread\include;..\..\..\..\..\openthread\src\core;..\..\..\..\..\openthread\third_party\NordicSemiconductor;..\..\..\..\..\openthread\third_party\NordicSemiconductor\cmsis;..\..\..\..\..\openthread\third_party\NordicSemiconductor\dependencies;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\clock;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\common;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\power;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\hal;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\mac_features;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\mac_features\ack_generator;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\rsch;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\rsch\raal;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\rsch\raal\softdevice;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\systick;..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\usbd;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\app_error;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\atfifo;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\atomic;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\crypto;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\delay;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\nrf_cc310\include;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb\class\cdc;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb\class\cdc\acm;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\usb\config;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\utf_converter;..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx;..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\drivers;..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\drivers\include;..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\hal;..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\mdk;..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\soc;..\..\..\..\..\openthread\third_party\NordicSemiconductor\softdevice\s140\headers;..\..\..\..\..\openthread\third_party\NordicSemiconductor\softdevice\s140\headers\nrf52;..\..\..\..\..\openthread\third_party\mbedtls;..\..\..\..\..\openthread\third_party\mbedtls\repo\include;..\..\..\..\..\openthread\third_party\mbedtls\repo\include\mbedtls
  asm define: as above
  asm misc: --cpreproc_opts=-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DHAVE_CONFIG_H,-DMBEDTLS_CONFIG_FILE=\"mbedtls-config.h\",-DMBEDTLS_USER_CONFIG_FILE=\"nrf52840-mbedtls-config.h\",-DNRF52840_XXAA,-DOPENTHREAD_CONFIG_ENABLE_SLAAC=1,-DOPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED,-DOPENTHREAD_ENABLE_NCP_SPI=1,-DOPENTHREAD_ENABLE_NCP_UART=0,-DOPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52840-config.h\",-DS140,-DSOFTDEVICE_PRESENT,-DSPIS_AS_SERIAL_TRANSPORT=1,-D_BSD_SOURCE=1,-D_DEFAULT_SOURCE=1,-D__HEAP_SIZE=4096,-D__STACK_SIZE=4096
  asm include: as above
  library: MicroLIB
  link misc: --diag_suppress 6330
  group openthread
    ../../../../../openthread/third_party/NordicSemiconductor/libraries/crypto/: aes_alt.c aes_alt_cc310.c aes_alt_soft.c cc310_mbedtls.c ecp_alt_cc310.c ecp_curves_alt.c sha256_alt_cc310.c
    ../../../../../openthread/examples/platforms/nrf52840/: alarm.c diag.c entropy.c fem.c flash.c flash_sd.c logging.c misc.c radio.c softdevice.c spi-slave.c system.c temp.c uart.c usb-cdc-uart.c
