# IAR project ot_nrf52840_libmbedcrypto_threadsafe_nrf52840.ewp, settings and files
configuration libmbedcrypto_threadsafe_nrf52840 (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DISABLE_CC310=1; FLOAT_ABI_HARD; HAVE_CONFIG_H; MBEDTLS_CONFIG_FILE="mbedtls-config.h"; MBEDTLS_THREADING=1; MBEDTLS_USER_CONFIG_FILE="nrf52840-mbedtls-config.h"; NRF52840_XXAA; OPENTHREAD_CONFIG_ENABLE_SLAAC=1; OPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED; OPENTHREAD_PROJECT_CORE_CONFIG_FILE="openthread-core-nrf52840-config.h"; UART_AS_SERIAL_TRANSPORT=1; _BSD_SOURCE=1; _DEFAULT_SOURCE=1
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\openthread\examples\platforms\nrf52840; ..\..\..\..\openthread\include; ..\..\..\..\openthread\src\core; ..\..\..\..\openthread\third_party\NordicSemiconductor\cmsis; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\crypto; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\nrf_cc310\include; ..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\mdk; ..\..\..\..\openthread\third_party\mbedtls; ..\..\..\..\openthread\third_party\mbedtls\repo\include; ..\..\..\..\openthread\third_party\mbedtls\repo\include\mbedtls
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ot_nrf52840_libmbedcrypto_threadsafe_nrf52840.hex
  ILINK.IlinkOutputFile: ot_nrf52840_libmbedcrypto_threadsafe_nrf52840.out
  ILINK.IlinkIcfFile: ot_nrf52840_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group openthread
    ../../../../openthread/third_party/mbedtls/repo/library/: aes.c asn1parse.c asn1write.c base64.c bignum.c ccm.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c md.c md_wrap.c memory_buffer_alloc.c oid.c pem.c pk.c pk_wrap.c pkparse.c platform.c platform_util.c sha256.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c x509.c x509_crt.c
