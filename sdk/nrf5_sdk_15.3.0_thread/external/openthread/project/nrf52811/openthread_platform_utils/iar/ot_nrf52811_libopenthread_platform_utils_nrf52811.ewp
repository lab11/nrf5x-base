# IAR project ot_nrf52811_libopenthread_platform_utils_nrf52811.ewp, settings and files
configuration libopenthread_platform_utils_nrf52811 (ARM)
  General.OGChipSelectEditMenu: nrf52811_xxaa nRF52811_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DISABLE_CC310=1; FLOAT_ABI_SOFT; HAVE_CONFIG_H; MBEDTLS_CONFIG_FILE="mbedtls-config.h"; MBEDTLS_USER_CONFIG_FILE="nrf52811-mbedtls-config.h"; NRF52811_XXAA; OPENTHREAD_CONFIG_ENABLE_SLAAC=1; OPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED; OPENTHREAD_PROJECT_CORE_CONFIG_FILE="openthread-core-nrf52811-config.h"; UART_AS_SERIAL_TRANSPORT=1; _BSD_SOURCE=1; _DEFAULT_SOURCE=1
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\openthread\examples\platforms; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..; ..\..\..\openthread\examples\platforms\nrf52811; ..\..\..\openthread\examples\platforms\utils; ..\..\..\openthread\include; ..\..\..\openthread\src\core; ..\..\..\openthread\third_party\NordicSemiconductor\cmsis; ..\..\..\openthread\third_party\NordicSemiconductor\libraries\crypto; ..\..\..\openthread\third_party\NordicSemiconductor\libraries\nrf_cc310\include; ..\..\..\openthread\third_party\NordicSemiconductor\nrfx\mdk; ..\..\..\openthread\third_party\jlink\SEGGER_RTT_V640\RTT; ..\..\..\openthread\third_party\mbedtls; ..\..\..\openthread\third_party\mbedtls\repo\include; ..\..\..\openthread\third_party\mbedtls\repo\include\mbedtls
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ot_nrf52811_libopenthread_platform_utils_nrf52811.hex
  ILINK.IlinkOutputFile: ot_nrf52811_libopenthread_platform_utils_nrf52811.out
  ILINK.IlinkIcfFile: ot_nrf52811_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group openthread
    ../../../openthread/examples/platforms/utils/: debug_uart.c logging_rtt.c settings_flash.c soft_source_match_table.c
