# Keil uVision project ot_nrf52811_libopenthread_platform_utils_nrf52811.uvprojx, settings and files
target libopenthread_platform_utils_nrf52811 (ARM-ADS)
  device: nRF52811_xxAA Nordic Semiconductor
  pack: ..
  output: libopenthread-platform-utils-nrf52811 (library)
  c flags: Optim=s OneElfS=1 uC99=1
  c define: DISABLE_CC310=1 FLOAT_ABI_SOFT HAVE_CONFIG_H MBEDTLS_CONFIG_FILE=\"mbedtls-config.h\" MBEDTLS_USER_CONFIG_FILE=\"nrf52811-mbedtls-config.h\" NRF52811_XXAA OPENTHREAD_CONFIG_ENABLE_SLAAC=1 OPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED OPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52811-config.h\" UART_AS_SERIAL_TRANSPORT=1 _BSD_SOURCE=1 _DEFAULT_SOURCE=1 __HEAP_SIZE=4096 __STACK_SIZE=4096
  c misc: --reduce_paths
  c include: ..\..\config;..\..\..\openthread\examples\platforms;..\..;..\..\..\openthread\examples\platforms\nrf52811;..\..\..\openthread\examples\platforms\utils;..\..\..\openthread\include;..\..\..\openthread\src\core;..\..\..\openthread\third_party\NordicSemiconductor\cmsis;..\..\..\openthread\third_party\NordicSemiconductor\libraries\crypto;..\..\..\openthread\third_party\NordicSemiconductor\libraries\nrf_cc310\include;..\..\..\openthread\third_party\NordicSemiconductor\nrfx\mdk;..\..\..\openthread\third_party\jlink\SEGGER_RTT_V640\RTT;..\..\..\openthread\third_party\mbedtls;..\..\..\openthread\third_party\mbedtls\repo\include;..\..\..\openthread\third_party\mbedtls\repo\include\mbedtls
  asm define: as above
  asm misc: --cpreproc_opts=-DDISABLE_CC310=1,-DFLOAT_ABI_SOFT,-DHAVE_CONFIG_H,-DMBEDTLS_CONFIG_FILE=\"mbedtls-config.h\",-DMBEDTLS_USER_CONFIG_FILE=\"nrf52811-mbedtls-config.h\",-DNRF52811_XXAA,-DOPENTHREAD_CONFIG_ENABLE_SLAAC=1,-DOPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED,-DOPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52811-config.h\",-DUART_AS_SERIAL_TRANSPORT=1,-D_BSD_SOURCE=1,-D_DEFAULT_SOURCE=1,-D__HEAP_SIZE=4096,-D__STACK_SIZE=4096
  asm include: as above
  library: MicroLIB
  link misc: --diag_suppress 6330
  group openthread
    ../../../openthread/examples/platforms/utils/: debug_uart.c logging_rtt.c settings_flash.c soft_source_match_table.c
