# Keil uVision project ot_nrf52811_libmbedcrypto_nrf52811.uvprojx, settings and files
target libmbedcrypto_nrf52811 (ARM-ADS)
  device: nRF52811_xxAA Nordic Semiconductor
  pack: ..
  output: libmbedcrypto-nrf52811 (library)
  c flags: Optim=s OneElfS=1 uC99=1
  c define: DISABLE_CC310=1 FLOAT_ABI_SOFT HAVE_CONFIG_H MBEDTLS_CONFIG_FILE=\"mbedtls-config.h\" MBEDTLS_USER_CONFIG_FILE=\"nrf52811-mbedtls-config.h\" NRF52811_XXAA OPENTHREAD_CONFIG_ENABLE_SLAAC=1 OPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED OPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52811-config.h\" UART_AS_SERIAL_TRANSPORT=1 _BSD_SOURCE=1 _DEFAULT_SOURCE=1 __HEAP_SIZE=4096 __STACK_SIZE=4096
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..;..\..\..\..\openthread\examples\platforms\nrf52811;..\..\..\..\openthread\include;..\..\..\..\openthread\src\core;..\..\..\..\openthread\third_party\NordicSemiconductor\cmsis;..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\crypto;..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\nrf_cc310\include;..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\mdk;..\..\..\..\openthread\third_party\mbedtls;..\..\..\..\openthread\third_party\mbedtls\repo\include;..\..\..\..\openthread\third_party\mbedtls\repo\include\mbedtls
  asm define: as above
  asm misc: --cpreproc_opts=-DDISABLE_CC310=1,-DFLOAT_ABI_SOFT,-DHAVE_CONFIG_H,-DMBEDTLS_CONFIG_FILE=\"mbedtls-config.h\",-DMBEDTLS_USER_CONFIG_FILE=\"nrf52811-mbedtls-config.h\",-DNRF52811_XXAA,-DOPENTHREAD_CONFIG_ENABLE_SLAAC=1,-DOPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED,-DOPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52811-config.h\",-DUART_AS_SERIAL_TRANSPORT=1,-D_BSD_SOURCE=1,-D_DEFAULT_SOURCE=1,-D__HEAP_SIZE=4096,-D__STACK_SIZE=4096
  asm include: as above
  library: MicroLIB
  link misc: --diag_suppress 6330
  group openthread
    ../../../../openthread/third_party/mbedtls/repo/library/: aes.c asn1parse.c asn1write.c base64.c bignum.c ccm.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c md.c md_wrap.c memory_buffer_alloc.c oid.c pem.c pk.c pk_wrap.c pkparse.c platform.c platform_util.c sha256.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c x509.c x509_crt.c
