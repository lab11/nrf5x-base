# IAR project ot_nrf52811_libopenthread_nrf52811_sdk_spi.ewp, settings and files
configuration libopenthread_nrf52811_sdk_spi (ARM)
  General.OGChipSelectEditMenu: nrf52811_xxaa nRF52811_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: CONFIG_GPIO_AS_PINRESET; DISABLE_CC310=1; FLOAT_ABI_SOFT; HAVE_CONFIG_H; MBEDTLS_CONFIG_FILE="mbedtls-config.h"; MBEDTLS_USER_CONFIG_FILE="nrf52811-mbedtls-config.h"; NRF52811_XXAA; OPENTHREAD_CONFIG_ENABLE_SLAAC=1; OPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED; OPENTHREAD_ENABLE_NCP_SPI=1; OPENTHREAD_ENABLE_NCP_UART=0; OPENTHREAD_PROJECT_CORE_CONFIG_FILE="openthread-core-nrf52811-config.h"; RAAL_SINGLE_PHY=1; SPIS_AS_SERIAL_TRANSPORT=1; _BSD_SOURCE=1; _DEFAULT_SOURCE=1
  ICCARM.CCIncludePath2: ..\..\..\..\config; ..\..\..\..\..\openthread\examples\platforms; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio; ..\..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..; ..\..\..\..\..\openthread\examples\platforms\nrf52811; ..\..\..\..\..\openthread\include; ..\..\..\..\..\openthread\src\core; ..\..\..\..\..\openthread\third_party\NordicSemiconductor; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\cmsis; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\dependencies; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\clock; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\common; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\power; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\hal; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\mac_features; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\mac_features\ack_generator; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\rsch; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\rsch\raal; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\systick; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\app_error; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\atfifo; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\atomic; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\crypto; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\delay; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\nrf_cc310\include; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\utf_converter; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\drivers; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\drivers\include; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\hal; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\mdk; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\soc; ..\..\..\..\..\openthread\third_party\mbedtls; ..\..\..\..\..\openthread\third_party\mbedtls\repo\include; ..\..\..\..\..\openthread\third_party\mbedtls\repo\include\mbedtls
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ot_nrf52811_libopenthread_nrf52811_sdk_spi.hex
  ILINK.IlinkOutputFile: ot_nrf52811_libopenthread_nrf52811_sdk_spi.out
  ILINK.IlinkIcfFile: ot_nrf52811_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group openthread
    ../../../../../openthread/examples/platforms/nrf52811/: alarm.c diag.c entropy.c fem.c flash.c flash_nosd.c logging.c misc.c radio.c spi-slave.c system.c temp.c uart.c
