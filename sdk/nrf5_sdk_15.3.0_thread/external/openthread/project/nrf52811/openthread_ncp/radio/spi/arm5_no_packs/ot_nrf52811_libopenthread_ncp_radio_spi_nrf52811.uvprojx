# Keil uVision project ot_nrf52811_libopenthread_ncp_radio_spi_nrf52811.uvprojx, settings and files
target libopenthread_ncp_radio_spi_nrf52811 (ARM-ADS)
  device: nRF52811_xxAA Nordic Semiconductor
  pack: ..
  output: libopenthread-ncp-radio-spi-nrf52811 (library)
  c flags: Optim=s OneElfS=1 uC99=1
  c define: DISABLE_CC310=1 FLOAT_ABI_SOFT HAVE_CONFIG_H MBEDTLS_CONFIG_FILE=\"mbedtls-config.h\" MBEDTLS_USER_CONFIG_FILE=\"nrf52811-mbedtls-config.h\" NRF52811_XXAA OPENTHREAD_CONFIG_ENABLE_SLAAC=1 OPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED OPENTHREAD_ENABLE_NCP_SPI=1 OPENTHREAD_ENABLE_NCP_UART=0 OPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52811-config.h\" OPENTHREAD_RADIO=1 SPINEL_PLATFORM_HEADER=\"spinel_platform.h\" SPIS_AS_SERIAL_TRANSPORT=1 _BSD_SOURCE=1 _DEFAULT_SOURCE=1 _GNU_SOURCE __HEAP_SIZE=4096 __STACK_SIZE=4096
  c misc: --reduce_paths
  c include: ..\..\..\..\config;..\..\..\..;..\..\..\..\..\openthread\examples\platforms\nrf52811;..\..\..\..\..\openthread\include;..\..\..\..\..\openthread\src;..\..\..\..\..\openthread\src\core;..\..\..\..\..\openthread\src\ncp;..\..\..\..\..\openthread\third_party;..\..\..\..\..\openthread\third_party\NordicSemiconductor\cmsis;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\crypto;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\nrf_cc310\include;..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\mdk;..\..\..\..\..\openthread\third_party\mbedtls;..\..\..\..\..\openthread\third_party\mbedtls\repo\include;..\..\..\..\..\openthread\third_party\mbedtls\repo\include\mbedtls
  asm define: as above
  asm misc: --cpreproc_opts=-DDISABLE_CC310=1,-DFLOAT_ABI_SOFT,-DHAVE_CONFIG_H,-DMBEDTLS_CONFIG_FILE=\"mbedtls-config.h\",-DMBEDTLS_USER_CONFIG_FILE=\"nrf52811-mbedtls-config.h\",-DNRF52811_XXAA,-DOPENTHREAD_CONFIG_ENABLE_SLAAC=1,-DOPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED,-DOPENTHREAD_ENABLE_NCP_SPI=1,-DOPENTHREAD_ENABLE_NCP_UART=0,-DOPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52811-config.h\",-DOPENTHREAD_RADIO=1,-DSPINEL_PLATFORM_HEADER=\"spinel_platform.h\",-DSPIS_AS_SERIAL_TRANSPORT=1,-D_BSD_SOURCE=1,-D_DEFAULT_SOURCE=1,-D_GNU_SOURCE,-D__HEAP_SIZE=4096,-D__STACK_SIZE=4096
  asm include: as above
  library: MicroLIB
  link misc: --diag_suppress 6330
  group openthread
    ../../../../../openthread/src/ncp/: changed_props_set.cpp hdlc.cpp ncp_base.cpp ncp_base_dispatcher.cpp ncp_base_ftd.cpp ncp_base_mtd.cpp ncp_base_radio.cpp ncp_buffer.cpp ncp_spi.cpp ncp_uart.cpp spinel.c spinel_decoder.cpp spinel_encoder.cpp
