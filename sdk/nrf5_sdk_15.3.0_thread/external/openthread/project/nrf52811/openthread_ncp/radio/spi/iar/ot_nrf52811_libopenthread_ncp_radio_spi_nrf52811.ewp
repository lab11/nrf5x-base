# IAR project ot_nrf52811_libopenthread_ncp_radio_spi_nrf52811.ewp, settings and files
configuration libopenthread_ncp_radio_spi_nrf52811 (ARM)
  General.OGChipSelectEditMenu: nrf52811_xxaa nRF52811_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DISABLE_CC310=1; FLOAT_ABI_SOFT; HAVE_CONFIG_H; MBEDTLS_CONFIG_FILE="mbedtls-config.h"; MBEDTLS_USER_CONFIG_FILE="nrf52811-mbedtls-config.h"; NRF52811_XXAA; OPENTHREAD_CONFIG_ENABLE_SLAAC=1; OPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED; OPENTHREAD_ENABLE_NCP_SPI=1; OPENTHREAD_ENABLE_NCP_UART=0; OPENTHREAD_PROJECT_CORE_CONFIG_FILE="openthread-core-nrf52811-config.h"; OPENTHREAD_RADIO=1; SPINEL_PLATFORM_HEADER="spinel_platform.h"; SPIS_AS_SERIAL_TRANSPORT=1; _BSD_SOURCE=1; _DEFAULT_SOURCE=1; _GNU_SOURCE
  ICCARM.CCIncludePath2: ..\..\..\..\config; ..\..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..; ..\..\..\..\..\openthread\examples\platforms\nrf52811; ..\..\..\..\..\openthread\include; ..\..\..\..\..\openthread\src; ..\..\..\..\..\openthread\src\core; ..\..\..\..\..\openthread\src\ncp; ..\..\..\..\..\openthread\third_party; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\cmsis; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\crypto; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\nrf_cc310\include; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\mdk; ..\..\..\..\..\openthread\third_party\mbedtls; ..\..\..\..\..\openthread\third_party\mbedtls\repo\include; ..\..\..\..\..\openthread\third_party\mbedtls\repo\include\mbedtls
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ot_nrf52811_libopenthread_ncp_radio_spi_nrf52811.hex
  ILINK.IlinkOutputFile: ot_nrf52811_libopenthread_ncp_radio_spi_nrf52811.out
  ILINK.IlinkIcfFile: ot_nrf52811_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group openthread
    ../../../../../openthread/src/ncp/: changed_props_set.cpp hdlc.cpp ncp_base.cpp ncp_base_dispatcher.cpp ncp_base_ftd.cpp ncp_base_mtd.cpp ncp_base_radio.cpp ncp_buffer.cpp ncp_spi.cpp ncp_uart.cpp spinel.c spinel_decoder.cpp spinel_encoder.cpp
