# Keil uVision project ot_nrf52811_libopenthread_mtd_nrf52811.uvprojx, settings and files
target libopenthread_mtd_nrf52811 (ARM-ADS)
  device: nRF52811_xxAA Nordic Semiconductor
  pack: ..
  output: libopenthread-mtd-nrf52811 (library)
  c flags: Optim=s OneElfS=1 uC99=1
  c define: DISABLE_CC310=1 FLOAT_ABI_SOFT HAVE_CONFIG_H MBEDTLS_CONFIG_FILE=\"mbedtls-config.h\" MBEDTLS_USER_CONFIG_FILE=\"nrf52811-mbedtls-config.h\" NRF52811_XXAA OPENTHREAD_CONFIG_ENABLE_SLAAC=1 OPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED OPENTHREAD_MTD=1 OPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52811-config.h\" UART_AS_SERIAL_TRANSPORT=1 _BSD_SOURCE=1 _DEFAULT_SOURCE=1 __HEAP_SIZE=4096 __STACK_SIZE=4096
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..;..\..\..\..\openthread\examples\platforms\nrf52811;..\..\..\..\openthread\include;..\..\..\..\openthread\src\core;..\..\..\..\openthread\third_party\NordicSemiconductor\cmsis;..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\crypto;..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\nrf_cc310\include;..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\mdk;..\..\..\..\openthread\third_party\mbedtls;..\..\..\..\openthread\third_party\mbedtls\repo\include;..\..\..\..\openthread\third_party\mbedtls\repo\include\mbedtls
  asm define: as above
  asm misc: --cpreproc_opts=-DDISABLE_CC310=1,-DFLOAT_ABI_SOFT,-DHAVE_CONFIG_H,-DMBEDTLS_CONFIG_FILE=\"mbedtls-config.h\",-DMBEDTLS_USER_CONFIG_FILE=\"nrf52811-mbedtls-config.h\",-DNRF52811_XXAA,-DOPENTHREAD_CONFIG_ENABLE_SLAAC=1,-DOPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED,-DOPENTHREAD_MTD=1,-DOPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52811-config.h\",-DUART_AS_SERIAL_TRANSPORT=1,-D_BSD_SOURCE=1,-D_DEFAULT_SOURCE=1,-D__HEAP_SIZE=4096,-D__STACK_SIZE=4096
  asm include: as above
  library: MicroLIB
  link misc: --diag_suppress 6330
  group openthread
    ../../../../openthread/src/core/thread/: address_resolver.cpp announce_begin_server.cpp announce_sender.cpp child_table.cpp data_poll_manager.cpp energy_scan_server.cpp key_manager.cpp link_quality.cpp lowpan.cpp mesh_forwarder.cpp mesh_forwarder_ftd.cpp mesh_forwarder_mtd.cpp mle.cpp mle_router.cpp network_data.cpp network_data_leader.cpp network_data_leader_ftd.cpp network_data_local.cpp network_diagnostic.cpp panid_query_server.cpp router_table.cpp src_match_controller.cpp thread_netif.cpp time_sync_service.cpp topology.cpp
    ../../../../openthread/src/core/crypto/: aes_ccm.cpp aes_ecb.cpp ecdsa.cpp hmac_sha256.cpp mbedtls.cpp pbkdf2_cmac.cpp sha256.cpp
    ../../../../openthread/src/core/meshcop/: announce_begin_client.cpp border_agent.cpp commissioner.cpp dataset.cpp dataset_local.cpp dataset_manager.cpp dataset_manager_ftd.cpp dtls.cpp energy_scan_client.cpp joiner.cpp joiner_router.cpp leader.cpp meshcop.cpp meshcop_tlvs.cpp panid_query_client.cpp timestamp.cpp
    ../../../../openthread/src/core/api/: border_router_api.cpp channel_manager_api.cpp channel_monitor_api.cpp child_supervision_api.cpp coap_api.cpp coap_secure_api.cpp commissioner_api.cpp crypto_api.cpp dataset_api.cpp dataset_ftd_api.cpp dns_api.cpp entropy_api.cpp icmp6_api.cpp instance_api.cpp ip6_api.cpp jam_detection_api.cpp joiner_api.cpp link_api.cpp link_raw_api.cpp logging_api.cpp message_api.cpp netdata_api.cpp network_time_api.cpp random_crypto_api.cpp random_noncrypto_api.cpp server_api.cpp sntp_api.cpp tasklet_api.cpp thread_api.cpp thread_ftd_api.cpp udp_api.cpp
    ../../../../openthread/src/core/utils/: channel_manager.cpp channel_monitor.cpp child_supervision.cpp heap.cpp jam_detector.cpp missing_strlcat.c missing_strlcpy.c missing_strnlen.c parse_cmdline.cpp slaac_address.cpp
    ../../../../openthread/src/core/mac/: channel_mask.cpp link_raw.cpp mac.cpp mac_filter.cpp mac_frame.cpp sub_mac.cpp sub_mac_callbacks.cpp
    ../../../../openthread/src/core/coap/: coap.cpp coap_message.cpp coap_secure.cpp
    ../../../../openthread/src/core/common/: crc16.cpp entropy.cpp instance.cpp logging.cpp message.cpp notifier.cpp random_crypto.cpp random_manager.cpp random_noncrypto.cpp settings.cpp string.cpp tasklet.cpp timer.cpp tlvs.cpp trickle_timer.cpp
    ../../../../openthread/src/core/net/: dhcp6_client.cpp dhcp6_server.cpp dns_client.cpp icmp6.cpp ip6.cpp ip6_address.cpp ip6_filter.cpp ip6_headers.cpp ip6_mpl.cpp ip6_routes.cpp netif.cpp sntp_client.cpp udp6.cpp
    ../../../../openthread/src/core/phy/: radio_weak.cpp
