# Keil uVision project openthread_lib_libopenthread_platform_utils.uvprojx, settings and files
target libopenthread_platform_utils (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: ..
  output: libopenthread-platform-utils (library)
  c flags: Optim=s OneElfS=1 uC99=1
  c define: FLOAT_ABI_HARD HAVE_CONFIG_H MBEDTLS_CONFIG_FILE=\"mbedtls-config.h\" MBEDTLS_USER_CONFIG_FILE=\"nrf52840-mbedtls-config.h\" NRF52840_XXAA OPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED OPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52840-config.h\" _BSD_SOURCE=1 _DEFAULT_SOURCE=1 __HEAP_SIZE=4096 __STACK_SIZE=4096
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\openthread\examples\platforms;..\..\..;..\..\..\openthread\examples\platforms\nrf52840;..\..\..\openthread\examples\platforms\utils;..\..\..\openthread\include;..\..\..\openthread\src\core;..\..\..\openthread\third_party\NordicSemiconductor\cmsis;..\..\..\openthread\third_party\NordicSemiconductor\libraries\crypto;..\..\..\openthread\third_party\NordicSemiconductor\libraries\nrf_cc310\include;..\..\..\openthread\third_party\NordicSemiconductor\nrfx\mdk;..\..\..\openthread\third_party\mbedtls;..\..\..\openthread\third_party\mbedtls\repo.patched\include;..\..\..\openthread\third_party\mbedtls\repo.patched\include\mbedtls
  asm define: as above
  asm misc: --cpreproc_opts=-DFLOAT_ABI_HARD,-DHAVE_CONFIG_H,-DMBEDTLS_CONFIG_FILE=\"mbedtls-config.h\",-DMBEDTLS_USER_CONFIG_FILE=\"nrf52840-mbedtls-config.h\",-DNRF52840_XXAA,-DOPENTHREAD_CONFIG_LOG_OUTPUT=OPENTHREAD_CONFIG_LOG_OUTPUT_PLATFORM_DEFINED,-DOPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52840-config.h\",-D_BSD_SOURCE=1,-D_DEFAULT_SOURCE=1,-D__HEAP_SIZE=4096,-D__STACK_SIZE=4096
  asm include: as above
  library: MicroLIB
  link misc: --diag_suppress 6330
  group openthread
    ../../../openthread/examples/platforms/utils/: debug_uart.c settings.cpp
